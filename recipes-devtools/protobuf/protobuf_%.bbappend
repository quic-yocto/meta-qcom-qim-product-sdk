EXTRA_OECONF += "--with-pic"
